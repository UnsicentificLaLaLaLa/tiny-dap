# Keil uVision project project.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: MM32F0163D7PV MindMotion
  pack: MindMotion.MM32F0160_DFP.0.0.5
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: fromelf --bin --output .\Objects\project.bin .\Objects\project.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: CFG_TUSB_MCU
  c include: ..\device;..\device\drivers;..\..\mm32f0160;..\..\..\application;..\..\..\third-party\CMSIS_5\CMSIS\Core\Include;..\..\..\third-party\CMSIS_5\CMSIS\DAP\Firmware\Include;..\..\..\third-party\tinyusb\src
  asm include: ..
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: ..\device\mdk\linker\mm32f0163d_flash.scf
  link misc: --keep=*_cb
  group application
    ../../../application/: main.c tusb_descriptors.c tusb_config.h
  group platform
    ../: platform.c platform.h DAP_config.h tusb_port.c uart_port.c
  group platform/device
    ../device/: hal_device_registers.h mm32f0163d.h mm32f0163d_features.h system_mm32f0163d.c system_mm32f0163d.h
    ../device/mdk/: startup_mm32f0163d.s
  group platform/device/drivers
    ../device/drivers/: hal_adc.c hal_adc.h hal_bkp.c hal_bkp.h hal_common.h hal_comp.c hal_comp.h hal_crc.c hal_crc.h hal_dma.c hal_dma.h hal_dma_request.h hal_exti.c hal_exti.h hal_flash.c hal_flash.h hal_flexcan.c hal_flexcan.h hal_gpio.c hal_gpio.h hal_hwdiv.c hal_hwdiv.h hal_i2c.c hal_i2c.h hal_i2s.c hal_i2s.h hal_i3c.c hal_i3c.h hal_iwdg.c hal_iwdg.h hal_lptim.c hal_lptim.h hal_lpuart.c hal_lpuart.h hal_power.c hal_power.h hal_pwr.c hal_pwr.h hal_rcc.c hal_rcc.h hal_rtc.c hal_rtc.h hal_spi.c hal_spi.h hal_syscfg.c hal_syscfg.h hal_tim.c hal_tim.h hal_uart.c hal_uart.h hal_usb.c hal_usb.h hal_usb_bdt.h hal_wwdg.c hal_wwdg.h
  group third-party/tinyusb
    ../../../third-party/tinyusb/src/: tusb.c
    ../../../third-party/tinyusb/src/common/: tusb_fifo.c
    ../../../third-party/tinyusb/src/device/: usbd.c usbd_control.c
    ../../../third-party/tinyusb/src/class/cdc/: cdc_device.c
    ../../../third-party/tinyusb/src/class/hid/: hid_device.c
  group third-party/cmsis-dap
    ../../../third-party/CMSIS_5/CMSIS/DAP/Firmware/Source/: DAP.c SW_DP.c
